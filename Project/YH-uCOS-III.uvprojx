# Keil uVision project YH-uCOS-III.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: YH-uCOS-III
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\User;..\User\uC-CPU;..\User\uC-LIB;..\User\uCOS-III\Ports;..\User\uCOS-III\Source
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: app.c
  group uC/OS-III Source
    ../User/uCOS-III/Source/: os.h os_task.c os_cfg.h os_var.c os_core.c
  group uC/OS-III Ports
    ../User/uCOS-III/Ports/: os_cpu_a.s
  group uC/CPU
    ../User/uC-CPU/: cpu.h os_cpu_c.c
  group Doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.2
